options:
  parameters:
    author: YD1RUH
    copyright: GNU
    generate_options: qt_gui
    id: Blade_duplex
    output_language: python
    run_options: run
    title: bladerf duplex
  states: {}

blocks:
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: rx gain
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.1'
    stop: '1'
    value: '0.3'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: sql
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,2,1
    label: Squelch
    orient: Qt.Horizontal
    rangeType: int
    start: '-50'
    step: '1'
    stop: '50'
    value: '-20'
    widget: slider
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: tx gain
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '10'
    value: '3'
    widget: slider
  states: {}
- name: analog_fm_demod_cf_0
  id: analog_fm_demod_cf
  parameters:
    audio_decim: '8'
    audio_pass: '16000'
    audio_stop: '20000'
    chan_rate: '384000'
    deviation: '75000'
    gain: '10'
    tau: '75e-6'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate*2
    tau: '75e-6'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: sql
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: pulse
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_gain
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: rx_gain
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: transmit.wav
    repeat: 'False'
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: '"bladerf"'
    bb_gain0: '20'
    bw0: '16000'
    freq0: '430000000'
    gain0: '50'
    if_gain0: '20'
    sample_rate: '2048000'
    sync: sync
    type: fc32
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: '"bladerf"'
    bb_gain0: '20'
    bw0: '500000'
    freq0: '450000000'
    gain0: '50'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: '2048000'
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    color1: '"green"'
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,1,5,1
    legend: 'False'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    axislabels: 'False'
    bw: samp_rate
    color1: '6'
    fc: '0'
    fftsize: '1024'
    gui_hint: 2,0,5,1
    legend: 'False'
    type: complex
    update_time: '0.1'
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: samp_rate*2
    interp: '2048000'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    taps: ''
    type: ccc
  states: {}

connections:
- [analog_fm_demod_cf_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [analog_simple_squelch_cc_0, '0', analog_fm_demod_cf_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_nbfm_tx_0, '0']
- [blocks_multiply_const_vxx_1, '0', audio_sink_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_1, '0']
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_1, '0', analog_simple_squelch_cc_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_1, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
